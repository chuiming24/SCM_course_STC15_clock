# Keil uVision project 任务四.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 任务四 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\allBuffer;.\allStat
  asm include: .\allBuffer;.\allStat;.\ouput
  group allBuffer
    ./allBuffer/: bufferInWatch.c bufferSetTime.c
  group allStat
    ./allStat/: inDownWatch.c inWatch.c setClockOne.c setClockTwo.c setTime.c showTime.c stat.c
  group main
    ./: dsp.c key.c main.c
